# Keil uVision project DIPLOMA.uvprojx, settings and files
target DIPLOMA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DIPLOMA
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\DIPLOMA;.\CMSIS\inc;.\Code\inc;.\StartUp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Code
    ./Code/src/: main.c DS18B20_Driver.c USART2.c TIM3.c ADC.c
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group StartUp
    ./StartUp/: startup_stm32f446xx.s
